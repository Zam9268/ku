# Keil uVision project My_3507_Project.uvprojx, settings and files
target My_3507 (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: My_3507_Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: __MSPM0G3507__
  c include: ..\source;..\source\third_party\CMSIS\Core\Include;.\Hardware;..\keil;.\ndrivers;.\Hardware\EXTI;.\Hardware\KEY;.\Hardware\SERVO;.\Hardware\LED_RGB;.\Hardware\BEEP;.\Hardware\TIME;.\Hardware\PWM;.\Hardware\SYSTEM;.\Hardware\encoder;.\Hardware\jy62;.\Hardware\LORA;.\Hardware\pid;.\Hardware\control;.\Hardware\OPENMV;.\Hardware\PROTOCOL;.\Hardware\MPU6050;.\Hardware\OLED
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group source
    ../source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c dl_adc12.h dl_aes.h dl_aesadv.h dl_common.h dl_comp.h dl_crc.h dl_crcp.h dl_dac12.h dl_dma.h dl_flashctl.h dl_gpamp.h dl_gpio.h dl_i2c.h dl_iwdt.h dl_keystorectl.h dl_lcd.h dl_lfss.h dl_mathacl.h dl_mcan.h dl_opa.h dl_rtc.h dl_rtc_a.h dl_rtc_common.h dl_scratchpad.h dl_spi.h dl_tamperio.h dl_timer.h dl_timera.h dl_timerg.h dl_trng.h dl_uart.h dl_uart_extend.h dl_uart_main.h dl_vref.h dl_wwdt.h driverlib.h
    ../source/ti/driverlib/m0p/: dl_interrupt.c dl_interrupt.h
    ../source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c dl_sysctl_mspm0g1x0x_g3x0x.h
  group ndrivers
    ./ndrivers/: binary.h drv_oled.c drv_oled.h glcdfont.c ssd1306.c ssd1306.h drv_spi.c drv_spi.h
  group hardware
    ./Hardware/EXTI/: EXTI.c
    ./Hardware/KEY/: KEY.c
    ./Hardware/SERVO/: SERVO.c
    ./Hardware/TIME/: TIME.c
    ./Hardware/LED_RGB/: LED_RGB.c
    ./Hardware/PWM/: PWM.c
    ./Hardware/SYSTEM/: system.c
    ./Hardware/BEEP/: beep.c
    ./Hardware/encoder/: encoder.c
    ./Hardware/jy62/: jy62.c
    ./Hardware/LORA/: lora.c
    ./Hardware/pid/: pid.c
    ./Hardware/control/: control.c
    ./Hardware/OPENMV/: openmv.c
    ./Hardware/PROTOCOL/: protocol.c
    ./Hardware/MPU6050/: bsp_mpu6050.c inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./Hardware/OLED/: OLED.c OLED_Data.c
  group user
    ./: gpio_toggle_output.syscfg ti_msp_dl_config.c ti_msp_dl_config.h main.c
    ../source/ti/devices/msp/m0p/startup_system_files/keil/: startup_mspm0g350x_uvision.s
